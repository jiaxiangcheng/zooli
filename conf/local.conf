## conf/local.conf
```bitbake
db_host = localhost
db_port = 3306
db_user = zooli
db_pass = 1234
db_name = zooli
db_type = mysql
EnableAdmin = true
AdminAddr = "localhost"
AdminPort = 8088
```
